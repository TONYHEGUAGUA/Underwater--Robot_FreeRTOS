# Keil uVision project Underwater Robot.uvprojx, settings and files
target Underwater Robot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Underwater Robot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Hardware\Timer\timer;..\Hardware\PWM;..\Hardware\Motor;..\Hardware\IMU;..\Hardware\IIC\IIC;..\Other\PID;..\Hardware\ADC;..\Hardware\Rain Sensor;..\FreeRTOS\Include;..\FreeRTOS\Source\portable\GCC;..\FreeRTOS\User;..\Other\SUM;..\Hardware\FreeRTOS_Timer_Source;..\Other\Move Average Filter
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Hardware
    ../Hardware/Timer/timer/: timer.c
    ../Hardware/PWM/: PWM.c
    ../Hardware/Motor/: motor.c
    ../Hardware/IMU/: imu.c
    ../Hardware/IIC/IIC/: myiic.c
    ../Hardware/ADC/: adc.c
    ../Hardware/Rain Sensor/: rain_sensor.c
    ../Hardware/FreeRTOS_Timer_Source/: freertos_timer_source.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Other
    ../Other/PID/: pid.c
    ../Other/SUM/: sum.c
    ../Other/Move Average Filter/: move_average_filter.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Source/portable/GCC/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
